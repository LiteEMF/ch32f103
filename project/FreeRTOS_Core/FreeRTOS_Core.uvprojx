# Keil uVision project FreeRTOS_Core.uvprojx, settings and files
target CH32F10x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CH32F103R8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F10x +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\SRC\StdPeriphDriver\inc;..\..\SRC\CMSIS;..\..\SRC\Debug;..\FreeRTOS_Core;.\FreeRTOS\Source\portable;.\FreeRTOS\Source\portable\MemMang;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\FreeRTOS\Source\portable\Common;.\FreeRTOS\Source\include;..\..\user;..\..\user\LiteEMF;..\..\user\emf_ch32fxxx_hal;..\..\user\emf_ch32fxxx_hal\usb;..\..\user\emf_ch32fxxx_hal\usb\USB-Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: ch32f10x_it.c Main.c system_ch32f10x.c
    ../../user/project/: gamepad1.c
  group startup
    ../../SRC/Startup/: startup_ch32f10x.s
  group core
    ../../SRC/CMSIS/: core_cm3.c
  group debug
    ../../SRC/Debug/: debug.c
  group peripheral
    ../../SRC/StdPeriphDriver/src/: ch32f10x_adc.c ch32f10x_bkp.c ch32f10x_can.c ch32f10x_crc.c ch32f10x_dac.c ch32f10x_dbgmcu.c ch32f10x_dma.c ch32f10x_exti.c ch32f10x_flash.c ch32f10x_gpio.c ch32f10x_i2c.c ch32f10x_iwdg.c ch32f10x_misc.c ch32f10x_pwr.c ch32f10x_rcc.c ch32f10x_rtc.c ch32f10x_spi.c ch32f10x_tim.c ch32f10x_usart.c ch32f10x_wwdg.c
  group freertosfiles
    ./FreeRTOS/Source/: timers.c tasks.c queue.c list.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group emf_app
    ../../user/LiteEMF/app/: app_battery.c app_command.c app_joystick.c app_key.c app_km.c app_led.c app_rumble.c emf.c io_key.c io_keyboard.c
    ../../user/LiteEMF/app/gamepad/: app_gamepad.c app_gamepad_key.c gamepad_controller.c ps_controller.c ps_crypt.c switch_controller.c switch_device.c switch_host.c switch_nfc.c turbo.c xbox_command.c xbox_controller.c xbox_device.c xbox_host.c
    ../../user/LiteEMF/app/imu/: app_imu.c imu_driver.c sh3001.c
    ../../user/LiteEMF/app/rgb/: app_rgb.c color_utils.c rgb_driver.c
  group emf_iap
    ../../user/LiteEMF/api/: api_gpio.c api_iic_host.c api_soft_timer.c api_spi_host.c api_system.c api_tick.c api_uart.c api_wdt.c pinmap.c api_log.c api_storage.c api_adc.c api_commander.c api_flash.c api_pm.c api_pwm.c api_timer.c api_transport.c
    ../../user/LiteEMF/api/wifi/: api_wifi.c
    ../../user/LiteEMF/api/usb/: usbd_socket.c usbh_socket.c
    ../../user/LiteEMF/api/usb/host/: usbh.c usbh_adb.c usbh_aoa.c usbh_audio.c usbh_cdc.c usbh_class.c usbh_core.c usbh_hid.c usbh_hid_gamepad.c usbh_hid_km.c usbh_hub.c usbh_iap2.c usbh_msd.c usbh_printer.c usbh_usbmuxd.c usbh_vendor.c
    ../../user/LiteEMF/api/usb/device/: usbd.c usbd_audio.c usbd_auto.c usbd_cdc.c usbd_class.c usbd_core.c usbd_hid.c usbd_hid_gamepade.c usbd_hid_km.c usbd_hid_mt.c usbd_hid_ps.c usbd_hid_switch.c usbd_hid_vendor.c usbd_hid_x360.c usbd_hid_xbox.c usbd_iap2.c usbd_msd.c usbd_printer.c usbd_msd_ram_disk.c usbd_msd_scsi.c
    ../../user/LiteEMF/api/nfc/: api_nfc.c nfc_driver.c
    ../../user/LiteEMF/api/hid/: hid_desc_parser.c hid_dev_desc.c
    ../../user/LiteEMF/api/bt/: api_bt.c bt_driver.c
    ../../user/LiteEMF/api/audio/: api_audio.c
  group emf_utils
    ../../user/LiteEMF/utils/: app_fifo.c at_commander.c check_sum.c emf_error.c emf_math.c emf_utils.c filter.c vector.c
    ../../user/LiteEMF/utils/mem/: emf_mem.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
    ../../user/LiteEMF/utils/crc/: crc_poly.c crc8.c crc16.c crc32.c
  group emf_hal
    ../../user/emf_ch32fxxx_hal/: hal_adc.c hal_audio.c hal_bt.c hal_flash.c hal_gpio.c hal_iic_host.c hal_log.c hal_pm.c hal_pwm.c hal_spi_host.c hal_system.c hal_tick.c hal_timer.c hal_uart.c hal_wdt.c hal_mem.c
    ../../user/emf_ch32fxxx_hal/usb/: hal_usbd.c hal_usbh.c hal_usbd_ch32dev.c
    ../../user/emf_ch32fxxx_hal/usb/USB-Driver/src/: usb_mem.c usb_regs.c
